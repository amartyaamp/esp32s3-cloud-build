## src/sdkconfig.defaults
```kconfig
CONFIG_LVGL_TICK_PERIOD_MS=2
CONFIG_LVGL_USE_LABEL=y
CONFIG_LVGL_FONT_MONTSERRAT_20=y
```
